File: LedBarController/0-10V.sch (KiCad schematic (older format))
At the start: 20 parts, among them J1101 Conn_01x02, J1102 Conn_01x02, U1101 LM358DR

Commit message: Reduced circuit by remove extra features. Routed whole board. Needs refinement
Parts:
- removed C1103: 1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- removed C1105: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- removed J1102: Conn_01x02, Connector_JST:JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical, symbol Connector_Generic:Conn_01x02
- removed R1105, R1107, R1108: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R
- removed R1106: 1k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R
- removed TP1103: a2, TestPoint:TestPoint_Pad_D1.0mm, symbol Connector:TestPoint
- removed TP1104: d2, TestPoint:TestPoint_Pad_D1.0mm, symbol Connector:TestPoint
Connections:
- net ain_2 is gone; now on an unnamed net: U1101.5 (+)
- net at U1101.6 (-): now also U1101.7
Other:
- note added: "Unused opamp, just wire it to some non GND, VDD,"
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 11 14
+Sheet 13 13
 Title ""
 Date ""
@@
 	6500 2950 6500 3050
 $Comp
-L Device:R R1107
-U 1 1 5F851870
-P 6500 5300
-F 0 "R1107" H 6430 5254 50  0000 R CNN
-F 1 "10k" H 6430 5345 50  0000 R CNN
-F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" V 6430 5300 50  0001 C CNN
-F 3 "~" H 6500 5300 50  0001 C CNN
-F 4 "10V_SUPPORTED_2CH" H 6500 5300 50  0001 C CNN "Feature"
-F 5 "0.0036" H 6500 5300 50  0001 C CNN "Price"
-F 6 "yes" H 6500 5300 50  0001 C CNN "is stock"
-	1    6500 5300
+L Device:C C1104
+U 1 1 5F9C8781
+P 7000 2250
+F 0 "C1104" H 7115 2296 50  0000 L CNN
+F 1 "0.1uF" H 7115 2205 50  0000 L CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder" H 7038 2100 50  0001 C CNN
+F 3 "~" H 7000 2250 50  0001 C CNN
+F 4 "10V_SUPPORTED_1CH" H 7000 2250 50  0001 C CNN "Feature"
+F 5 "0.0057" H 7000 2250 50  0001 C CNN "Price"
+F 6 "yes" H 7000 2250 50  0001 C CNN "is stock"
+	1    7000 2250
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	7000 2400 7000 2500
+Connection ~ 7000 2500
+Wire Wire Line
+	7000 2500 7150 2500
+$Comp
+L power:GND #PWR01109
+U 1 1 5F9CDC23
+P 7000 2000
+F 0 "#PWR01109" H 7000 1750 50  0001 C CNN
+F 1 "GND" H 7005 1827 50  0000 C CNN
+F 2 "" H 7000 2000 50  0001 C CNN
+F 3 "" H 7000 2000 50  0001 C CNN
+	1    7000 2000
 	-1   0    0    1
 $EndComp
-$Comp
-L Device:R R1108
-U 1 1 5F851876
-P 6500 5800
-F 0 "R1108" H 6430 5754 50  0000 R CNN
-F 1 "10k" H 6430 5845 50  0000 R CNN
-F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" V 6430 5800 50  0001 C CNN
-F 3 "~" H 6500 5800 50  0001 C CNN
-F 4 "10V_SUPPORTED_2CH" H 6500 5800 50  0001 C CNN "Feature"
-F 5 "0.0036" H 6500 5800 50  0001 C CNN "Price"
-F 6 "yes" H 6500 5800 50  0001 C CNN "is stock"
-	1    6500 5800
-	-1   0    0    1
-$EndComp
-$Comp
-L power:GND #PWR01108
-U 1 1 5F851880
-P 6500 6050
-F 0 "#PWR01108" H 6500 5800 50  0001 C CNN
-F 1 "GND" H 6505 5877 50  0000 C CNN
-F 2 "" H 6500 6050 50  0001 C CNN
-F 3 "" H 6500 6050 50  0001 C CNN
-	1    6500 6050
-	1    0    0    -1
-$EndComp
-Wire Wire Line
-	6500 5950 6500 6050
-$Comp
-L Connector_Generic:Conn_01x02 J1102
-U 1 1 5F85188A
-P 7350 5000
-F 0 "J1102" H 7430 4992 50  0000 L CNN
-F 1 "Conn_01x02" H 7430 4901 50  0000 L CNN
-F 2 "Connector_JST:JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical" H 7350 5000 50  0001 C CNN
-F 3 "~" H 7350 5000 50  0001 C CNN
-F 4 "10V_SUPPORTED_2CH" H 7350 5000 50  0001 C CNN "Feature"
-F 5 "0.0097" H 7350 5000 50  0001 C CNN "Price"
-F 6 "yes" H 7350 5000 50  0001 C CNN "is stock"
-	1    7350 5000
-	1    0    0    -1
-$EndComp
-$Comp
-L power:GND #PWR01107
-U 1 1 5F851890
-P 7000 5250
-F 0 "#PWR01107" H 7000 5000 50  0001 C CNN
-F 1 "GND" H 7005 5077 50  0000 C CNN
-F 2 "" H 7000 5250 50  0001 C CNN
-F 3 "" H 7000 5250 50  0001 C CNN
-	1    7000 5250
-	1    0    0    -1
-$EndComp
-Wire Wire Line
-	7150 5100 7000 5100
-Wire Wire Line
-	7000 5100 7000 5250
-$Comp
-L Device:R R1106
-U 1 1 5F8518AA
-P 6500 4800
-F 0 "R1106" H 6430 4754 50  0000 R CNN
-F 1 "1k" H 6430 4845 50  0000 R CNN
-F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" V 6430 4800 50  0001 C CNN
-F 3 "~" H 6500 4800 50  0001 C CNN
-F 4 "10V_SUPPORTED_2CH" H 6500 4800 50  0001 C CNN "Feature"
-F 5 "0.0036" H 6500 4800 50  0001 C CNN "Price"
-F 6 "yes" H 6500 4800 50  0001 C CNN "is stock"
-	1    6500 4800
-	-1   0    0    1
-$EndComp
-Wire Wire Line
-	6350 4600 6500 4600
-Wire Wire Line
-	6500 4600 6500 4650
-Wire Wire Line
-	6500 4950 6500 5000
-Wire Wire Line
-	6500 5000 7000 5000
-Connection ~ 6500 5000
-Wire Wire Line
-	6500 5000 6500 5150
-Wire Wire Line
-	5500 4700 5500 5550
-Wire Wire Line
-	4250 4500 4600 4500
-Connection ~ 4250 4500
-Wire Wire Line
-	4250 4450 4250 4500
-$Comp
-L Connector:TestPoint TP1104
-U 1 1 5F8518A1
-P 4250 4450
-F 0 "TP1104" H 4308 4568 50  0000 L CNN
-F 1 "d2" H 4308 4477 50  0000 L CNN
-F 2 "TestPoint:TestPoint_Pad_D1.0mm" H 4450 4450 50  0001 C CNN
-F 3 "~" H 4450 4450 50  0001 C CNN
-F 4 "10V_SUPPORTED_2CH" H 4250 4450 50  0001 C CNN "Feature"
-F 5 "0" H 4250 4450 50  0001 C CNN "Price"
-F 6 "n.a." H 4250 4450 50  0001 C CNN "is stock"
-	1    4250 4450
-	1    0    0    -1
-$EndComp
-Wire Wire Line
-	4250 3950 4250 4000
-Wire Wire Line
-	4250 4000 5000 4000
-Connection ~ 4250 4000
-$Comp
-L Connector:TestPoint TP1103
-U 1 1 5F851898
-P 4250 3950
-F 0 "TP1103" H 4308 4068 50  0000 L CNN
-F 1 "a2" H 4308 3977 50  0000 L CNN
-F 2 "TestPoint:TestPoint_Pad_D1.0mm" H 4450 3950 50  0001 C CNN
-F 3 "~" H 4450 3950 50  0001 C CNN
-F 4 "10V_SUPPORTED_2CH" H 4250 3950 50  0001 C CNN "Feature"
-F 5 "0" H 4250 3950 50  0001 C CNN "Price"
-F 6 "n.a." H 4250 3950 50  0001 C CNN "is stock"
-	1    4250 3950
-	1    0    0    -1
-$EndComp
-Wire Wire Line
-	4000 4500 4250 4500
-Wire Wire Line
-	4000 4000 4250 4000
-Wire Wire Line
-	5000 4000 5000 4500
-Wire Wire Line
-	5500 5550 6500 5550
-Wire Wire Line
-	5750 4700 5500 4700
-Connection ~ 5000 4500
-Wire Wire Line
-	5000 4500 5750 4500
-Wire Wire Line
-	5000 4900 5000 5000
-$Comp
-L power:GND #PWR01106
-U 1 1 5F851867
-P 5000 5000
-F 0 "#PWR01106" H 5000 4750 50  0001 C CNN
-F 1 "GND" H 5005 4827 50  0000 C CNN
-F 2 "" H 5000 5000 50  0001 C CNN
-F 3 "" H 5000 5000 50  0001 C CNN
-	1    5000 5000
-	1    0    0    -1
-$EndComp
-Wire Wire Line
-	5000 4500 5000 4600
-Wire Wire Line
-	4900 4500 5000 4500
-$Comp
-L Device:C C1103
-U 1 1 5F85185F
-P 5000 4750
-F 0 "C1103" H 5115 4796 50  0000 L CNN
-F 1 "1uF" H 5115 4705 50  0000 L CNN
-F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder" H 5038 4600 50  0001 C CNN
-F 3 "~" H 5000 4750 50  0001 C CNN
-F 4 "10V_SUPPORTED_2CH" H 5000 4750 50  0001 C CNN "Feature"
-F 5 "0.015" H 5000 4750 50  0001 C CNN "Price"
-F 6 "no" H 5000 4750 50  0001 C CNN "is stock"
-	1    5000 4750
-	1    0    0    -1
-$EndComp
-$Comp
-L Device:R R1105
-U 1 1 5F851859
-P 4750 4500
-F 0 "R1105" V 4543 4500 50  0000 C CNN
-F 1 "10k" V 4634 4500 50  0000 C CNN
-F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" V 4680 4500 50  0001 C CNN
-F 3 "~" H 4750 4500 50  0001 C CNN
-F 4 "10V_SUPPORTED_2CH" H 4750 4500 50  0001 C CNN "Feature"
-F 5 "0.0036" H 4750 4500 50  0001 C CNN "Price"
-F 6 "yes" H 4750 4500 50  0001 C CNN "is stock"
-	1    4750 4500
-	0    1    1    0
-$EndComp
-Text HLabel 4000 4000 0    50   Output ~ 0
-ain_2
-Text HLabel 4000 4500 0    50   Input ~ 0
-dout_2
+Wire Wire Line
+	7000 2000 7000 2100
 $Comp
 L Amplifier_Operational:LM358 U1101
@@
 $EndComp
 Wire Wire Line
-	6500 5450 6500 5550
-Connection ~ 6500 5550
-Wire Wire Line
-	6500 5550 6500 5650
-$Comp
-L Device:C C1105
-U 1 1 5F9C7EB5
-P 7000 4750
-F 0 "C1105" H 7115 4796 50  0000 L CNN
-F 1 "0.1uF" H 7115 4705 50  0000 L CNN
-F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder" H 7038 4600 50  0001 C CNN
-F 3 "~" H 7000 4750 50  0001 C CNN
-F 4 "10V_SUPPORTED_2CH" H 7000 4750 50  0001 C CNN "Feature"
-F 5 "0.0057" H 7000 4750 50  0001 C CNN "Price"
-F 6 "yes" H 7000 4750 50  0001 C CNN "is stock"
-	1    7000 4750
-	1    0    0    -1
-$EndComp
-$Comp
-L Device:C C1104
-U 1 1 5F9C8781
-P 7000 2250
-F 0 "C1104" H 7115 2296 50  0000 L CNN
-F 1 "0.1uF" H 7115 2205 50  0000 L CNN
-F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder" H 7038 2100 50  0001 C CNN
-F 3 "~" H 7000 2250 50  0001 C CNN
-F 4 "10V_SUPPORTED_1CH" H 7000 2250 50  0001 C CNN "Feature"
-F 5 "0.0057" H 7000 2250 50  0001 C CNN "Price"
-F 6 "yes" H 7000 2250 50  0001 C CNN "is stock"
-	1    7000 2250
-	1    0    0    -1
-$EndComp
-Wire Wire Line
-	7000 2400 7000 2500
-Connection ~ 7000 2500
-Wire Wire Line
-	7000 2500 7150 2500
-Wire Wire Line
-	7000 4900 7000 5000
-Connection ~ 7000 5000
-Wire Wire Line
-	7000 5000 7150 5000
-$Comp
-L power:GND #PWR01110
-U 1 1 5F9CAF62
-P 7000 4450
-F 0 "#PWR01110" H 7000 4200 50  0001 C CNN
-F 1 "GND" H 7005 4277 50  0000 C CNN
-F 2 "" H 7000 4450 50  0001 C CNN
-F 3 "" H 7000 4450 50  0001 C CNN
-	1    7000 4450
-	-1   0    0    1
-$EndComp
-Wire Wire Line
-	7000 4450 7000 4600
-$Comp
-L power:GND #PWR01109
-U 1 1 5F9CDC23
-P 7000 2000
-F 0 "#PWR01109" H 7000 1750 50  0001 C CNN
-F 1 "GND" H 7005 1827 50  0000 C CNN
-F 2 "" H 7000 2000 50  0001 C CNN
-F 3 "" H 7000 2000 50  0001 C CNN
-	1    7000 2000
-	-1   0    0    1
-$EndComp
-Wire Wire Line
-	7000 2000 7000 2100
+	5500 3050 5500 4500
+Wire Wire Line
+	5500 4500 5750 4500
+Connection ~ 5500 3050
+Wire Wire Line
+	6350 4600 6500 4600
+Wire Wire Line
+	6500 4600 6500 5000
+Wire Wire Line
+	6500 5000 5500 5000
+Wire Wire Line
+	5500 5000 5500 4700
+Wire Wire Line
+	5500 4700 5750 4700
+Text Notes 5500 4050 0    50   ~ 0
+Unused opamp, just wire it to some non GND, VDD,
 $EndSCHEMATC

Commit message: Route complete
Parts:
- added C1103: 1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- added C1105: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- added J1102: Conn_01x02, TerminalBlock_TE-Connectivity:TerminalBlock_TE_282834-2_1x02_P2.54mm_Horizontal, symbol Connector_Generic:Conn_01x02
- added R1105, R1107, R1108: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R
- added R1106: 1k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R
- added TP1103: d2, TestPoint:TestPoint_Pad_D1.0mm, symbol Connector:TestPoint
- added TP1104: a2, TestPoint:TestPoint_Pad_D1.0mm, symbol Connector:TestPoint
- J1101: footprint Connector_JST:JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal -> TerminalBlock_TE-Connectivity:TerminalBlock_TE_282834-2_1x02_P2.54mm_Horizontal
- U1101: value LM358DR -> LM393; Price 0.033 -> 0.036
- U1101: value LM358DR -> LM393
Connections:
- net GND: now also C1103.2, C1105.1, J1102.2 (Pin_2), R1108.1
- net at R1103.1, R1104.2, U1101.2 (-): no longer U1101.5 (+)
- net at U1101.6 (-): now also R1107.1, R1108.2; no longer U1101.7
- net ain_1: no longer names the net of C1101.1, R1101.1, TP1101.1, U1101.3 (+)
- net dout_1 renamed pwm1
- new net: C1103.1, R1105.1, TP1104.1, U1101.5 (+)
- new net: R1106.2, U1101.7
- new net: C1105.2, J1102.1 (Pin_1), R1106.1, R1107.2
- new net pwm2: R1105.2, TP1103.1
Other:
- note removed: "Unused opamp, just wire it to some non GND, VDD,"
