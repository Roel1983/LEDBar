# Repository Roel1983/LEDBar

## KiCad design LedBarController/LedBarController.kicad_pcb

Parts:
J101, J102, J104, J105: Conn_01x05; LED_Strip_10mm_5pins_Left
J103, J109: Male pitch strip 1x7 pins 2.0mm pitch; PinHeader_1x05_P2.00mm_Vertical
J106: Male pitch strip 2x7pins 2.0mm pitch; PinHeader_2x07_P2.00mm_Vertical
J107, J108, J110, J111: Conn_01x05; LED_Strip_10mm_5pins_Right
SW101: 4x42.3mm PCB Tactile Push Button Switch; SW_SPST_SKQG_WithStem

Connections:
/blue_left_front: J101.4, J102.4, J103.4
/center_front_l_blue: J104.4, J105.4, J106.10
/center_front_l_green: J104.2, J105.2, J106.6
/center_front_l_red: J104.3, J105.3, J106.8
/center_front_l_white: J104.5, J105.5, J106.12
/center_front_r_blue: J106.9, J107.4, J108.4
/center_front_r_green: J106.5, J107.2, J108.2
/center_front_r_red: J106.7, J107.3, J108.3
/center_front_r_white: J106.11, J107.5, J108.5
/center_front_vdd: J104.1, J105.1, J106.1, J106.2, J106.3, J106.4, J107.1, J108.1
/gnd: J106.13, SW101.1
/left_front_green: J101.2, J102.2, J103.2
/left_front_vdd: J101.1, J102.1, J103.1
/red_left_front: J101.3, J102.3, J103.3
/right_front_blue: J109.4, J110.4, J111.4
/right_front_green: J109.2, J110.2, J111.2
/right_front_red: J109.3, J110.3, J111.3
/right_front_vdd: J109.1, J110.1, J111.1
/right_front_white: J109.5, J110.5, J111.5
/white_left_front: J101.5, J102.5, J103.5
/~button~: J106.14, SW101.2

Notes on the sheet:
Board: Left Front
Board: Center Front
Board: Right Front
Wire x 5

Parts:
C301, C303, C304, C305, C306: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C302: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C307: 10uF/35V; CP_EIA-6032-28_Kemet-C_Pad2.25x2.35mm_HandSolder
C308: 10uF/10V; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
D302: SMBJ15A; D_SMB_Handsoldering
D303: Blue; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F301: max. 5A F; Fuseholder_Cylinder-5x20mm_BLX_A_Horizontal
J301: Barrel_Jack_Switch; BarrelJack_CUI_PJ-102AH_Horizontal
R301, R302: 10R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R303: R001/2W; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R304: 100, 1W; R_1812_4532Metric_Pad1.30x3.40mm_HandSolder
R306: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP301: VDD; TestPoint_Pad_D1.0mm
TP302: 5V+; TestPoint_Pad_D1.0mm
TP303: GND; TestPoint_Pad_D1.0mm
U301: INA219AxD; SOIC-8_3.9x4.9mm_P1.27mm
U302: AMS1117-5.0; SOT-223-3_TabPin2

Connections:
/CenterBack/Microcontroller/scl: U301.4 (SCL); also elsewhere on the board
/CenterBack/Microcontroller/sda: U301.3 (SDA); also elsewhere on the board
unnamed: C305.1, C307.1, R304.1, U302.3 (VI)
unnamed: D303.2 (A), R306.2
unnamed: F301.2, J301.1
unnamed: R301.2, U301.8 (IN+)
unnamed: R302.2, U301.7 (IN-)

Notes on the sheet:
Over current and voltage protection
Voltage and current measurement

Parts:
C401, C402, C403, C406: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C404, C405: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D401: Green; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D402: Yellow; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D403: Orange; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D404: Red; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J401: ISP; ISP_P1.27mm_single_row
JP401, JP402, JP403, JP404, JP405: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R401: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R402, R403: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RN401: 10k; R_Array_Concave_4x0603
SW401: reset; SW_SPST_CK_RS282G05A3
U401: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm_corner_cutoff
U402: AT24C256; SOP-8_3.76x4.96mm_P1.27mm
Y401: 14.7456Mhz; Crystal_HC49-U_Vertical_tight_fit

Connections:
/CenterBack/0-10V/pwm1: U401.9 (PD5(5)); also elsewhere on the board
/CenterBack/0-10V/pwm2: U401.10 (PD6(6)); also elsewhere on the board
/CenterBack/Microcontroller/addr1: JP401.1 (A), U401.1 (PD3(3))
/CenterBack/Microcontroller/addr2: JP402.1 (A), U401.2 (PD4(4))
/CenterBack/Microcontroller/addr3: JP403.1 (A), U401.11 (PD7(7))
/CenterBack/Microcontroller/addr4: JP404.1 (A), U401.12 (PB0(8))
/CenterBack/Microcontroller/addr5: JP405.1 (A), U401.13 (PB1(9))
/CenterBack/Microcontroller/aref: C403.1, U401.20 (AREF)
/CenterBack/Microcontroller/isp_miso: J401.1 (MISO), RN401.3 (R3.1), U401.16 (PB4(12))
/CenterBack/Microcontroller/isp_mosi: J401.4 (MOSI), RN401.4 (R4.1), U401.15 (PB3(11))
/CenterBack/Microcontroller/isp_sck: J401.3 (SCK), RN401.2 (R2.1), U401.17 (PB5(13))
/CenterBack/Microcontroller/led1: RN401.1 (R1.1), U401.14 (PB2(10))
/CenterBack/Microcontroller/reset: J401.5 (~RST), R401.2, SW401.1, U401.29 (~RESET~/PC6(22))
/CenterBack/Microcontroller/rxd: U401.30 (PD0(0)); also elsewhere on the board
/CenterBack/Microcontroller/scl: R402.2, U401.28 (PC5(A5/19)), U402.6 (SCL); also elsewhere on the board
/CenterBack/Microcontroller/sda: R403.2, U401.27 (PC4(A4/18)), U402.5 (SDA); also elsewhere on the board
/CenterBack/Microcontroller/tx_en: U401.26 (PC3(A3/17)); also elsewhere on the board
/CenterBack/Microcontroller/txd: U401.31 (PD1(1)); also elsewhere on the board
/CenterBack/Microcontroller/~button~: U401.23 (PC0(A0/14)); also elsewhere on the board
/CenterBack/PWM/~oe: U401.32 (PD2(2)); also elsewhere on the board
unnamed: C404.1, U401.7 (XTAL1/PB6(20)), Y401.2
unnamed: C405.1, U401.8 (XTAL2/PB7(21)), Y401.1
unnamed: D401.2 (A), RN401.8 (R1.2)
unnamed: D402.2 (A), RN401.5 (R4.2)
unnamed: D403.2 (A), RN401.6 (R3.2)
unnamed: D404.2 (A), RN401.7 (R2.2)

Parts:
C501: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J501: Screw_Terminal_01x03; TerminalBlock_TE_282834-3_1x03_P2.54mm_Horizontal
JP501: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
R501, R503: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R502: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP501: B; TestPoint_Pad_D1.0mm
TP502: A; TestPoint_Pad_D1.0mm
U501: MAX485E; SOP-8_3.76x4.96mm_P1.27mm

Connections:
/CenterBack/Microcontroller/rxd: U501.1 (RO); also elsewhere on the board
/CenterBack/Microcontroller/tx_en: U501.2 (~RE), U501.3 (DE); also elsewhere on the board
/CenterBack/Microcontroller/txd: U501.4 (DI); also elsewhere on the board
/CenterBack/RS485/A: J501.2, R502.2, R503.1, TP502.1, U501.6 (A)
/CenterBack/RS485/B: J501.1, JP501.1 (A), R501.2, TP501.1, U501.7 (B)
unnamed: JP501.2 (B), R502.1

Parts:
C601, C602, C604: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C603, C605: 470uF/35V; CP_Radial_D13.0mm_P5.00mm
J601, J603: Female pitch strip 1x7 pins 2.0mm pitch; PinHeader_1x05_P2.00mm_Vertical
J602: Female 2x7 pins 2.0mm pitch; PinSocket_2x07_P2.00mm_Vertical
Q601, Q602, Q603, Q604, Q605, Q606, Q607, Q608, Q609, Q610, Q611, Q612, Q613, Q614, Q615, Q616: Si2302DS; SOT-23_Handsoldering
U601: PCA9685PW; TSSOP-28_4.4x9.7mm_P0.65mm

Connections:
/CenterBack/Microcontroller/scl: U601.26 (SCL); also elsewhere on the board
/CenterBack/Microcontroller/sda: U601.27 (SDA); also elsewhere on the board
/CenterBack/Microcontroller/~button~: J602.14; also elsewhere on the board
/CenterBack/PWM/strip1_b: Q603.1 (G), U601.8 (LED2)
/CenterBack/PWM/strip1_b_out: J601.4, Q603.3 (D)
/CenterBack/PWM/strip1_g: Q602.1 (G), U601.7 (LED1)
/CenterBack/PWM/strip1_g_out: J601.2, Q602.3 (D)
/CenterBack/PWM/strip1_r: Q601.1 (G), U601.6 (LED0)
/CenterBack/PWM/strip1_r_out: J601.3, Q601.3 (D)
/CenterBack/PWM/strip1_w: Q604.1 (G), U601.9 (LED3)
/CenterBack/PWM/strip1_w_out: J601.5, Q604.3 (D)
/CenterBack/PWM/strip2_b: Q607.1 (G), U601.12 (LED6)
/CenterBack/PWM/strip2_b_out: J602.10, Q607.3 (D)
/CenterBack/PWM/strip2_g: Q606.1 (G), U601.11 (LED5)
/CenterBack/PWM/strip2_g_out: J602.6, Q606.3 (D)
/CenterBack/PWM/strip2_r: Q605.1 (G), U601.10 (LED4)
/CenterBack/PWM/strip2_r_out: J602.8, Q605.3 (D)
/CenterBack/PWM/strip2_w: Q608.1 (G), U601.13 (LED7)
/CenterBack/PWM/strip2_w_out: J602.12, Q608.3 (D)
/CenterBack/PWM/strip3_b: Q611.1 (G), U601.17 (LED10)
/CenterBack/PWM/strip3_b_out: J602.9, Q611.3 (D)
/CenterBack/PWM/strip3_g: Q610.1 (G), U601.16 (LED9)
/CenterBack/PWM/strip3_g_out: J602.5, Q610.3 (D)
/CenterBack/PWM/strip3_r: Q609.1 (G), U601.15 (LED8)
/CenterBack/PWM/strip3_r_out: J602.7, Q609.3 (D)
/CenterBack/PWM/strip3_w: Q612.1 (G), U601.18 (LED11)
/CenterBack/PWM/strip3_w_out: J602.11, Q612.3 (D)
/CenterBack/PWM/strip4_b: Q615.1 (G), U601.21 (LED14)
/CenterBack/PWM/strip4_b_out: J603.4, Q615.3 (D)
/CenterBack/PWM/strip4_g: Q614.1 (G), U601.20 (LED13)
/CenterBack/PWM/strip4_g_out: J603.2, Q614.3 (D)
/CenterBack/PWM/strip4_r: Q613.1 (G), U601.19 (LED12)
/CenterBack/PWM/strip4_r_out: J603.3, Q613.3 (D)
/CenterBack/PWM/strip4_w: Q616.1 (G), U601.22 (LED15)
/CenterBack/PWM/strip4_w_out: J603.5, Q616.3 (D)
/CenterBack/PWM/~oe: U601.23 (~OE); also elsewhere on the board

Parts:
C701, C704: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C702, C703, C705: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J701, J702: Conn_01x02; TerminalBlock_TE_282834-2_1x02_P2.54mm_Horizontal
R701, R705: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R702, R706: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R703, R704, R707, R708: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U701: LM393; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
/CenterBack/0-10V/pwm1: R701.2; also elsewhere on the board
/CenterBack/0-10V/pwm2: R705.2; also elsewhere on the board
unnamed: C701.1, R701.1, U701.3 (+)
unnamed: C704.1, R705.1, U701.5 (+)
unnamed: R703.1, R704.2, U701.2 (-)
unnamed: R707.1, R708.2, U701.6 (-)

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
Board: 2 copper layers, 100.0 x 100.0 mm, 111 parts (67 on the bottom side), 101 nets.

Other parts of the board:
D301: 10V; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
Q301: FQP47P06; TO-220-3_Vertical
R305: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Their connections:
unnamed: D301.2, Q301.1, R305.1

## Commit log

2020-10-08 Work in progress
2020-10-09 Restarted PCB
2020-10-10 Routed Power circuit
2020-10-11 Just before reverse order of strips
2020-10-11 Before moving down the center connector
2020-10-11 Some
2020-10-11 Pwm circuit routed (no plane yet)
2020-10-11 Added fill zones
2020-10-12 Changed components and moved center connector upwards
2020-10-12 Routed center board
2020-10-13 Added side boards
2020-10-14 Updated schematic, added ds1307, replaced gpio-headers for LEDs and solder-jumpers and remove ISP-connector
2020-10-14 Added capacitor for DS1307 and changed package of MAX485
2020-10-15 Updated labels in schematic and moved RTC to sub-schematic
2020-10-15 Added missing capacitor for MAX485
2020-10-15 routed RS485 circuit
2020-10-15 Routed LEDs and solder jumpers, renumbered diodes (and LEDs) on microcontroller schematic
2020-10-15 Routed resistor-pack
2020-10-15 Added INA219 current/voltage sensor
2020-10-24 Changed Something dont known anymore
2020-10-25 Reduced circuit by remove extra features. Routed whole board. Needs refinement
2020-10-25 Added surge protection
2020-10-25 Added surge protection on power input
2020-10-25 Update silk layer
2020-10-25 Improved ISP connector silk layer
2020-10-25 Added AT24C256
2020-10-25 Updated slik layer
2020-10-26 Refined routing
2020-10-31 Route complete
2020-10-31 Added custom footprint for LED strip connection
2020-10-31 moved board on schema to same sheet
2020-10-31 Moved FETs to PWM sheet
2020-10-31 Rearanged sheets
2020-10-31 Reanotate
2020-11-01 Updated footprints and Fab layer
2020-11-01 Improved description text on silklayer
2020-11-01 Test Git-hooks
2020-11-01 Added auto date and version numbering
2020-11-01 Test commit hook
2020-11-01 Test commit-hook
2020-11-01 Test
2020-11-01 Changed Dwgs.User layer
2020-11-01 Removed generated pdf files
2020-11-01 Removed another generated pdf-file
2020-11-01 Replaced git-URL placeholder for the real git-URL
2020-11-03 Fixed minor issues
2020-11-04 Minnor changes
2020-11-05 Minor changes
2020-11-06 Disabled precommit hook
2020-11-07 prepared panelization
2020-11-07 Hide silkscreen of the side boards, so we can use them upside down too
2020-11-07 Added dots at pin 1
2020-12-13 Added pdf of schematic
2021-02-02 Adds clamb 3D model
2021-04-12 Working at bootloader
2021-04-12 Added 3D shapes
2021-04-12 Added test firmware mess
2021-04-12 Just added the mess, I'll clean up later. I promisegit add ../3D/drawing.svg!
2021-04-12 Removed Revere voltage protection circuit. I gets to hot! Replaced VTS diode from bidirectional to directional
2021-04-12 Added pull-up resistor to 1-10V output
2021-04-12 Improved RC filter for 1-10V
2021-04-12 Changed address for INA219 from 0x40 to 0x44
2021-04-12 Replaced 470R for 10k resistor to make the LED less bright
2021-04-12 Added Arduino pin-numbers to ATMega328 symbol
2021-04-13 increased size of pin-holes of power connector
2021-04-13 Changed size and value of Capacitor C603 and C605
2021-04-15 Fixed shunt filter for INA219
2021-04-15 Added more testpoints
